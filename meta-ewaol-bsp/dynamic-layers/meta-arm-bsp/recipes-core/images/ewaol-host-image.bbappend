# Copyright (c) 2021, Arm Limited.
#
# SPDX-License-Identifier: MIT

EWAOL_WIC_IMAGE_EXTRA_DEPENDS:n1sdp ?= "xen:do_deploy xen-devicetree:do_deploy"
