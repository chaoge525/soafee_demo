require ewaol-image-core.inc

SUMMARY = "EWAOL Image with podman runtime."

IMAGE_INSTALL += "podman"
