# Copyright (c) 2022, Arm Limited.
#
# SPDX-License-Identifier: MIT

# Upstream project source code moved from master to main branch
# Change based on https://git.yoctoproject.org/meta-virtualization/commit/?h=hardknott&id=5f3650880ec887263b6e4ab160c11ed7dffd32c2
SRC_URI = "git://${PKG_NAME}.git;branch=main;protocol=https"
